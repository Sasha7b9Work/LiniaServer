# Keil uVision project Panel.uvprojx, settings and files
target Debug (6210000::V6.21::.\ARMCLANG539)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Panel +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=2
  c define: USE_HAL_DRIVER, DEBUG, PANEL, STM32F429xx, USE_USB_HS, USE_USB_HS_IN_FS, USE_USB_FS
  c include: ..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;.\src\Hardware\HAL;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;.\src;..\common;..\common\libs;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\FlashDrive;..\common\FlashDrive\USBH;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\VCP\USBD;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include;..\common\libs\LwIP;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\system
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Panel.sct
  group HAL
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_tim.h stm32f4xx_hal_dma.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_hcd.h
    ../common/libs/STM32Cube_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_spi.c stm32f4xx_hal_hcd.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_eth.c
  group src
    ./src/: main.cpp no-warnings.h defines.h
  group Connector/Device
    ../common/Connector/Device/: Messages_.cpp Messages_.h Transceiver_.h Value_.h
    ./src/Connector/Device/: Messages_p.cpp Handlers_p.cpp Handlers_p.h Interface_p.cpp Interface_p.h Transceiver_p.cpp
  group Device
    ./src/Device/: Device.cpp Device.h IT6523.cpp IT6523.h
  group Display
    ../common/Display/: Colors_.cpp Colors_.h Console_.cpp Console_.h Display_.cpp Display_.h Display_stm_.cpp Primitives_.cpp Primitives_.h Symbols_.cpp Symbols_.h Text_.cpp Text_.h
    ./src/Display/: Painter.cpp Painter.h
  group Display/Font
    ../common/Display/Font/: Font.cpp Font.h FontBig.cpp FontBig.h fontGOSTAU16BOLD.inc fontGOSTB28B.inc FontMid.cpp FontMid.h
  group Display/Pictures
    ./src/Display/Pictures/: Picture.cpp Picture.h Signal1.inc Signal2a.inc Signal2b.inc Signal3a.inc Signal3b.inc Signal4.inc Signal5a.inc Signal5b.inc Scheme1.inc Scheme2.inc
  group FlashDrive
    ../common/FlashDrive/: ffconf.h FileManager.cpp FileManager.h FlashDrive.cpp FlashDrive.h
    ../common/FlashDrive/USBH/: usbh_conf.cpp usbh_conf.h usbh_diskio.cpp usbh_diskio.h
  group Hardware
    ./src/Hardware/: Timer.cpp Timer.h Beeper.cpp Beeper.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: system_stm32f4xx.c startup_stm32f429xx.s
    ./src/: no-warnings.h
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL.cpp HAL_EEPROM.cpp HAL_FSMC.cpp HAL_IT.cpp HAL_TIM.cpp stm32f4xx_hal_conf.h HAL_PINS.cpp HAL_PINS.h
    ../common/Hardware/HAL/: HAL_SPI1_p_.cpp HAL_RTC_.cpp
  group Hardware/Keyboard
    ../common/Hardware/Keyboard/: Keyboard_.cpp Keyboard_.h
  group LAN
    ./src/LAN/: LAN.cpp LAN.h app_ethernet.h ethernetif.h httpd_cgi_ssi.cpp app_ethernet.cpp ethernetif.cpp http_cgi_ssi.h fsdata_custom.c ClientTCP.cpp ClientTCP.h ServerTCP.cpp ServerTCP.h
  group Menu
    ./src/Menu/: Menu.cpp Menu.h MenuItems.cpp MenuItems.h MenuItemsDef.h ParameterDrawStruct.cpp ParameterDrawStruct.h
  group Menu/Pages
    ./src/Menu/Pages/: PageMain.cpp Pages.h PageSignal1.cpp PageSignal2a.cpp PageSignal2b.cpp PageSignal3a.cpp PageSignal3b.cpp PageSignal4.cpp PageSignal5a.cpp PageSignal5b.cpp PageSettings.cpp PageInfo.cpp PageLAN.cpp PageCalibration.cpp InputField.cpp InputField.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h
  group SCPI
    ./src/SCPI/: SCPI.cpp SCPI.h RingBuffer.cpp RingBuffer.h Commands.cpp Commands.h Parser.cpp Parser.h
  group VCP
    ../common/VCP/: VCP.cpp VCP.h
    ../common/VCP/USBD/: usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_conf.cpp usbd_conf.h usbd_desc.cpp usbd_desc.h
  group Utils
    ../common/Utils/: List_.cpp List_.h StringUtils_.cpp StringUtils_.h Math_.cpp Math_.h Stack_.cpp Stack_.h Buffer_.h Debug_.cpp Debug_.h Log_.cpp Log_.h Buffer_.cpp
  group libs/FatFS
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/: ff.c ff.h ff_gen_drv.c ff_gen_drv.h diskio.c diskio.h
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group libs/miniz
    ../common/libs/miniz/: miniz.c miniz.h miniz_tinfl.c miniz_tdef.c miniz_zip.c
  group libs/USBD
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group libs/USBH
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_pipes.c usbh_ctlreq.c usbh_ioreq.c
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Inc/: usbh_core.h usbh_pipes.h usbh_ctlreq.h usbh_ioreq.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc/: usbh_msc.h usbh_msc_bot.h usbh_msc_scsi.h
    ../common/libs/STM32Cube_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group libs/LwIP
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/: init.c netif.c def.c tcp_out.c memp.c pbuf.c mem.c tcp_in.c udp.c tcp.c ip.c inet_chksum.c timeouts.c
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/apps/http/: httpd.c fs.c
    ../common/libs/STM32Cube_F4/Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4.c ip4_frag.c dhcp.c etharp.c ip4_addr.c icmp.c
target Release (6210000::V6.21::ARMCLANG)
  device: STM32F429VITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: Panel +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=2
  c define: USE_HAL_DRIVER, PANEL, STM32F429xx, USE_USB_HS, USE_USB_HS_IN_FS, USE_USB_FS
  c include: ..\common\libs\STM32Cube_F4\Drivers\STM32F4xx_HAL_Driver\Inc;.\src\Hardware\HAL;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\common\libs\STM32Cube_F4\Drivers\CMSIS\Include;.\src;..\common;..\common\libs;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\FatFs\src;..\common\libs\FatFS;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\common\FlashDrive;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\VCP\USBD;..\common\libs\STM32Cube_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\src\include;..\common\libs\LwIP;..\common\libs\STM32Cube_F4\Middlewares\Third_Party\LwIP\system;.\src\LAN;..\common\FlashDrive\USBH
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Panel.sct
